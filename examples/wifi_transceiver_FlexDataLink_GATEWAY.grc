<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_transceiver_FlexDataLink_GATEWAY</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.52e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interval</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mac_addr</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xaa]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mac_coord</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xaa]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mac_dst</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xab]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>1000e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>1000e-3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/wifi_rx_all.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/tmp/wifi_tx_all.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>440</value></param>
</block>
<block>
<key>data_link</key>
<param><key>id</key><value>data_link_0</value></param>
<param><key>alpha</key><value>1000</value></param>
<param><key>mac_bss</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
<param><key>mac_coord</key><value>mac_coord</value></param>
<param><key>comment</key><value>Protocol:
	- CSMA/CA = 0
	- TDMA = 1

Coordinator: True/ False</value></param>
<param><key>coord</key><value>True</value></param>
<param><key>mac_dst</key><value>mac_dst</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>portid</key><value>255</value></param>
<param><key>mac_src</key><value>mac_addr</value></param>
<param><key>samp_rate</key><value>5e6</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>somac_decision</key>
<param><key>id</key><value>somac_decision_0</value></param>
<param><key>aggr0</key><value>2</value></param>
<param><key>aggr1</key><value>1</value></param>
<param><key>aggr2</key><value>1</value></param>
<param><key>aggr3</key><value>1</value></param>
<param><key>aggr4</key><value>1</value></param>
<param><key>aggr5</key><value>1</value></param>
<param><key>aggr6</key><value>1</value></param>
<param><key>aggr7</key><value>2</value></param>
<param><key>aggr8</key><value>1</value></param>
<param><key>backlog_file</key><value>/tmp/backlog_file.npy</value></param>
<param><key>broad_gran</key><value>5</value></param>
<param><key>coord</key><value>True</value></param>
<param><key>dec_gran</key><value>30</value></param>
<param><key>ml_alg</key><value>0</value></param>
<param><key>metrics_gran</key><value>30</value></param>
<param><key>train_file</key><value>/tmp/training_file.npy</value></param>
<param><key>onoff_learn</key><value>1</value></param>
</block>
<block>
<key>somac_metrics_gen</key>
<param><key>id</key><value>somac_metrics_gen_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>somac_sensor</key>
<param><key>id</key><value>somac_sensor_0</value></param>
<param><key>is_coord</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mac</key><value>mac_addr</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>10e6</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>10e6</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>pdus</source_key><sink_key>tap in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>buff size</source_key><sink_key>bsz in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>buffer out</source_key><sink_key>buffer in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>new frame out</source_key><sink_key>new frame in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>foo_wireshark_connector_0_0</sink_block_id><source_key>phy out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>phy out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>snr out</source_key><sink_key>snr in</sink_key></connection>
<connection><source_block_id>data_link_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>tap out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>somac_decision_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>broad out</source_key><sink_key>broad in</sink_key></connection>
<connection><source_block_id>somac_decision_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>ctrl out</source_key><sink_key>prot switch</sink_key></connection>
<connection><source_block_id>somac_decision_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>metrics out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>somac_metrics_gen_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>broad out</source_key><sink_key>metrics in</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>act prot out</source_key><sink_key>act prot in</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met buffsize</source_key><sink_key>met in8</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met contention</source_key><sink_key>met in6</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met interpkt</source_key><sink_key>met in4</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met jit</source_key><sink_key>met in2</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met lat</source_key><sink_key>met in1</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met non</source_key><sink_key>met in7</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met pkt_thr</source_key><sink_key>met in9</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met rnp</source_key><sink_key>met in3</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met snr</source_key><sink_key>met in5</sink_key></connection>
<connection><source_block_id>somac_sensor_0</source_block_id><sink_block_id>somac_decision_0</sink_block_id><source_key>met thr</source_key><sink_key>met in0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>data_link_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>somac_metrics_gen_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>somac_sensor_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

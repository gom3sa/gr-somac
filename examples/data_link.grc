<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>data_link</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Flex Data Link Layer</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>coord</value></param>
<param><key>label</key><value>Coordinator</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>csma_threshold</value></param>
<param><key>label</key><value>CSMA threshold (dB)</value></param>
<param><key>value</key><value>-35</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug</value></param>
<param><key>label</key><value>Debug mode</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>ieee802_11_ether_encap</key>
<param><key>id</key><value>ieee802_11_ether_encap_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0</value></param>
<param><key>bss_mac</key><value>mac_bss</value></param>
<param><key>dst_mac</key><value>mac_dst</value></param>
<param><key>src_mac</key><value>mac_src</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mac_bss</value></param>
<param><key>label</key><value>BSS MAC</value></param>
<param><key>value</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mac_coord</value></param>
<param><key>label</key><value>COORD MAC</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xaa]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mac_dst</value></param>
<param><key>label</key><value>DST MAC</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xab]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mac_src</value></param>
<param><key>label</key><value>SRC MAC</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x78,0x90,0xaa]</value></param>
</block>
<block>
<key>macprotocols_csma_ca</key>
<param><key>id</key><value>macprotocols_csma_ca_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>debug</key><value>debug</value></param>
<param><key>difs</key><value>34</value></param>
<param><key>src_mac</key><value>mac_src</value></param>
<param><key>sifs</key><value>16</value></param>
<param><key>slot_time</key><value>9</value></param>
<param><key>threshold</key><value>csma_threshold</value></param>
</block>
<block>
<key>macprotocols_frame_buffer</key>
<param><key>id</key><value>macprotocols_frame_buffer_0</value></param>
<param><key>buff_size</key><value>256</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>portid</key><value>portid</value></param>
<param><key>arp</key><value>True</value></param>
</block>
<block>
<key>macprotocols_myswitch</key>
<param><key>id</key><value>macprotocols_myswitch_0</value></param>
<param><key>portid</key><value>portid</value></param>
</block>
<block>
<key>macprotocols_myswitch</key>
<param><key>id</key><value>macprotocols_myswitch_0_0</value></param>
<param><key>portid</key><value>portid</value></param>
</block>
<block>
<key>macprotocols_naive_tdma</key>
<param><key>id</key><value>macprotocols_naive_tdma_0</value></param>
<param><key>alpha</key><value>1000</value></param>
<param><key>is_coord</key><value>coord</value></param>
<param><key>debug</key><value>debug</value></param>
<param><key>src_mac</key><value>mac_src</value></param>
<param><key>slot_time</key><value>5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>phy out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>tap out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>buffer out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>snr out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>new frame out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>buff size</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>tap in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>rx_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>phy in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3</value></param>
<param><key>label</key><value>prot switch</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3_0</value></param>
<param><key>label</key><value>broad in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3_0_0</value></param>
<param><key>label</key><value>metrics in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>portid</value></param>
<param><key>comment</key><value>- CSMA/CA: 0
- TDMA: 1</value></param>
<param><key>label</key><value>Protocol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sampling rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>somac_broadcaster</key>
<param><key>id</key><value>somac_broadcaster_0</value></param>
<param><key>mac_addr</key><value>mac_src</value></param>
</block>
<block>
<key>somac_metrics_frame</key>
<param><key>id</key><value>somac_metrics_frame_0</value></param>
<param><key>mac_addr_coord</key><value>mac_coord</value></param>
<param><key>mac_addr</key><value>mac_src</value></param>
</block>
<block>
<key>somac_snr</key>
<param><key>id</key><value>somac_snr_0</value></param>
<param><key>periodicity</key><value>5</value></param>
<param><key>threshold</key><value>-60</value></param>
<param><key>window_size</key><value>1024</value></param>
</block>
<block>
<key>toolkit_cs</key>
<param><key>id</key><value>toolkit_cs_0</value></param>
</block>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>somac_snr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>toolkit_cs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>to tap</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>ieee802_11_mac_0</sink_block_id><source_key>to wifi</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>phy out</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>phy out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>frame request</source_key><sink_key>req in 0</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>frame to app</source_key><sink_key>from wifi</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>macprotocols_myswitch_0_0</sink_block_id><source_key>frame to phy</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>toolkit_cs_0</sink_block_id><source_key>request to cs</source_key><sink_key>in_msg</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>bsz out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>frame out 0</source_key><sink_key>frame from buffer</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>frame out 0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>macprotocols_naive_tdma_0</sink_block_id><source_key>frame out 1</source_key><sink_key>frame from buffer</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>frame out 1</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>frame out 2</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_myswitch_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>out0</source_key><sink_key>frame from phy</sink_key></connection>
<connection><source_block_id>macprotocols_myswitch_0</source_block_id><sink_block_id>macprotocols_naive_tdma_0</sink_block_id><source_key>out1</source_key><sink_key>frame from phy</sink_key></connection>
<connection><source_block_id>macprotocols_myswitch_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_myswitch_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out1</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_naive_tdma_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>frame request</source_key><sink_key>req in 1</sink_key></connection>
<connection><source_block_id>macprotocols_naive_tdma_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>frame to app</source_key><sink_key>from wifi</sink_key></connection>
<connection><source_block_id>macprotocols_naive_tdma_0</source_block_id><sink_block_id>macprotocols_myswitch_0_0</sink_block_id><source_key>frame to phy</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>out</source_key><sink_key>from tap</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>macprotocols_myswitch_0</sink_block_id><source_key>out</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>macprotocols_myswitch_0</sink_block_id><source_key>out</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>macprotocols_myswitch_0</sink_block_id><source_key>out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>macprotocols_myswitch_0_0</sink_block_id><source_key>out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>pad_source_3_0</source_block_id><sink_block_id>somac_broadcaster_0</sink_block_id><source_key>out</source_key><sink_key>msg in</sink_key></connection>
<connection><source_block_id>pad_source_3_0_0</source_block_id><sink_block_id>somac_metrics_frame_0</sink_block_id><source_key>out</source_key><sink_key>msg in</sink_key></connection>
<connection><source_block_id>somac_broadcaster_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>frame out</source_key><sink_key>broad in</sink_key></connection>
<connection><source_block_id>somac_metrics_frame_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>frame out</source_key><sink_key>metrics in</sink_key></connection>
<connection><source_block_id>somac_snr_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>snr out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>toolkit_cs_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>out_msg</source_key><sink_key>cs in</sink_key></connection>
</flow_graph>
